Properties of the parts of a building model (IFC2X3)

# File
Description: Tauchhülse, 400 mm, V4A 1.4571, Durchmesser InnenxAußen 6,3 x 9 mm, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9990210, Tauchhülse, 400 mm, V4A 1.4571, Durchmesser InnenxAußen 6,3 x 9 mm
In: Raum
Description: Tauchhülse, 400 mm, V4A 1.4571, Durchmesser Innen x Außen 6,3 x 9 mm, für Hülsenfühler HF und Kabelfühler KF mit Durchmesser 6 mm sowie Einbau- und Industriekanalfühler EKF/IKF; Classification: EC010502 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9990210; ModelLabel: THV/400; GlobalTradeItemNumber: 4050528044143; ProductURL: https://alre.de/produkt_G9990210
Pset_Specification - NominalLength: 0.413 m; NominalWidth: 0.022 m; NominalDepth: 0.022 m; NetWeight: 0.148
Pset_ALRE_ETIM_Properties - Außendurchmesser: 9; Innendurchmesser: 6.3; Werkstoffgüte: Edelstahl 316 Ti (1.4571); Druckstufe Artikel: PN 40; Material Tauchrohr: rostfreier Stahl; Einstecklänge: 400; Nenndurchmesser Anschluss: 1/2 Zoll (15); ETIM-Klasse: EC010502; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9990210.pdf
